# IAR project beer_machine.ewp, settings and files
configuration beer_machine (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RC ST STM32F103RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xE
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Drivers/CMSIS/Include; ../Src/board; ../Src/utils; ../Src/debug/log; ../Src/debug/cpu; ../Src/debug/log/SEGGER_RTT_V612j/RTT; ../Src/debug/log/SEGGER_RTT_V612j/Syscalls; ../Src/serial; ../Src/http; ../Src/net; ../Src/tasks; ../Src/gsm; ../Src/wifi; ../Src/at; ../Src/md5; ../Src/ntp; ../Src/socket; ../Src/led; ../Src/utils; ../Src/tm1629a; ../Src/bootloader_if; ../Src/flash_utils; ../Src/firmware_version; ../Src/cjson
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\\Inc
  OBJCOPY.OOCOutputFile: beer_machine.bin
  ILINK.IlinkOutputFile: beer_machine.out
  ILINK.IlinkIcfFile: stm32f103xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../Src/: adc.c dma.c freertos.c gpio.c iwdg.c main.c spi.c stm32f1xx_hal_msp.c stm32f1xx_it.c usart.c
  group Application/User/at
    ../Src/at/: at.c
  group Application/User/board
    ../Src/board/: beer_machine.c st_capacity_serial.c st_gsm_serial.c st_wifi_serial.c
  group Application/User/bootloader_if
    ../Src/bootloader_if/: bootloader_if.c
  group Application/User/debug/cpu
    ../Src/debug/cpu/: cpu_utils.c
  group Application/User/debug/log
    ../Src/debug/log/: log.c
  group Application/User/debug/log/segger_rtt
    ../Src/debug/log/SEGGER_RTT_V612j/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../Src/debug/log/SEGGER_RTT_V612j/Syscalls/: SEGGER_RTT_Syscalls_IAR.c
  group Application/User/flash_utils
    ../Src/flash_utils/: flash_utils.c
  group Application/User/gsm
    ../Src/gsm/: gsm_m6312.c
  group Application/User/http
    ../Src/http/: http_client.c
  group Application/User/json
    ../Src/cjson/: cJSON.c cJSON_Utils.c
  group Application/User/led
    ../Src/led/: led.c
  group Application/User/md5
    ../Src/md5/: md5.c
  group Application/User/net
    ../Src/net/: net.c
  group Application/User/ntp
    ../Src/ntp/: ntp.c
  group Application/User/serial
    ../Src/serial/: serial.c
  group Application/User/socket
    ../Src/socket/: socket.c
  group Application/User/tasks
    ../Src/tasks/: adc_task.c alarm_task.c capacity_task.c compressor_task.c display_task.c net_task.c pressure_task.c report_task.c tasks_init.c temperature_task.c
  group Application/User/tm1629a
    ../Src/tm1629a/: tm1629a.c
  group Application/User/tools
    ../Src/utils/: utils.c
  group Application/User/wifi
    ../Src/wifi/: wifi_8710bx.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
